# Keil uVision project main.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.1
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Test
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Driver\inc;.\Utilities\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLLx\S32K144_64_flash.sct
  group Source Group 1
    ./: main.c
  group Driver
    ./Driver/scr/: Clock.c GPIO.c Nvic.c Port.c Systick.c Lpit.c Lpspi.c Lpuart.c
  group Utilities
    ./Utilities/src/: Config.c MAX7219.c ProcessDateTime.c String.c UART_Processing.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0
